options:
  parameters:
    generate_options: qt_gui
    id: ModularAMG1C
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitu portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {state: disabled}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia de portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1e3
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente de sensibilidad AM
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/8
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {state: disabled}
- name: CalculoPotencia_J1C_04_0
  id: CalculoPotencia_J1C_04
  parameters:
    l_vect: '1024'
  states: {}
- name: ModuladorSSB_0
  id: ModuladorSSB
  parameters:
    Ac: Ac
    B: B
    k: K
  states: {}
- name: ModuloAm_0
  id: ModuloAm
  parameters:
    Ac: Ac
    ka: ka
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Comm_G1C_4/edacecar_korsakov_bumblebee.wav
    repeat: 'True'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorSSB_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorSSB_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorSSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotencia_J1C_04_0, '0']
- [analog_sig_source_x_0, '0', ModuladorSSB_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
